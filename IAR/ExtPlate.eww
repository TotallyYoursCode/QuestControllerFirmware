<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ExtPlate.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\I2C Master (stm8l-discovery)\IAR\project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


