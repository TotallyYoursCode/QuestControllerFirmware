# IAR project ExtPlate.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x180
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: ..\StdPeriph\inc; ..\; C:\Program Files (x86)\Arduino\libraries\ExtPins; ..\..\extpins
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ExtPlate.srec
  ILINK.IlinkOutputFile: extplate.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenStackSize: 0x100
  ICCSTM8.CCDefines: NDEBUG
  ILINK.IlinkOutputFile: ExtPlate.out
  group (top)
    ../: board.c i2c_comm.c main.c stm8s_it.c
  group Lib
    ../: crc8.c
  group StdPeriph
    ../StdPeriph/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart2.c stm8s_wwdg.c
